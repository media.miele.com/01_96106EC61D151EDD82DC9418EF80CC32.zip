Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-22T07:12:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 22 07:12:10 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\b8d37697-5476-4c36-a776-ddc260fa4c5a\218e98ae-c040-4c1c-a90d-9982275d1a4b\ifc * Database version: 5507 * Database creation date: Tue Feb 22 07:12:09 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 22 07:12:10 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 22 07:12:10 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11878520_USA_DAS4720_EDST:28S4720S_USA_11878520_DAS4720_EDST, (2)
In: Default
Type - Material: Výchozí Nový materiál
Type - Pset_BuildingElementProxyCommon - Reference: 28S4720S_USA_11878520_DAS4720_EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28S4720S_USA_11878520_DAS4720_EDST
Material: Výchozí Nový materiál, z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Plast
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 758 mm; Height: 436 mm; Depth: 273 mm

# IfcDistributionPort, Port_354280
Description: Flow; FlowDirection: SOURCEANDSINK
